# IAR project freertos_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4; HAL_CLOCK_ENABLED
  ICCARM.CCIncludePath2: application\led; application; board\MKL46Z; FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\include; FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\portable\IAR\ARM_CM0; CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: application
  OBJCOPY.OOCOutputFile: freertos_project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: board\MKL46Z\MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    application/: main.c
  group Application/led/inc
    application/led/: LED.h
  group Application/led/src
    application/led/: LED.c
  group board/inc
    board/MKL46Z/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h system_MKL46Z4.h
  group board/linker
    board/MKL46Z/: MKL46Z256xxx4_flash.icf
  group board/src
    board/MKL46Z/: system_MKL46Z4.c
  group board/startup
    board/MKL46Z/: startup_MKL46Z4.s
  group CMSIS/inc
    CMSIS/Include/: core_cm0plus.h
  group FreeRTOS/config
    application/: FreeRTOSConfig.h
  group FreeRTOS/inc
    FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/portable/inc
    FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: portmacro.h
  group FreeRTOS/portable/src
    FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/src
    FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
