# IAR project FreeRTOS_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Application\led\inc; board\inc; CMSIS\inc; FreeRTOS\config; FreeRTOS\inc; FreeRTOS\portable\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; FreeRTOS\portable\inc; FreeRTOS\inc; Application\led\inc; Application; board\inc; CMSIS\inc
  OBJCOPY.OOCOutputFile: FreeRTOS_project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: board\linker\MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group Application/led/inc
    Application/led/inc/: INIT.h LED.h
  group Application/led/src
    Application/led/src/: INIT.c LED.c
  group board/inc
    board/inc/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h system_MKL46Z4.h
  group board/linker
    board/linker/: MKL46Z256xxx4_flash.icf
  group board/src
    board/src/: system_MKL46Z4.c
  group board/startup
    board/startup/: startup_MKL46Z4.s
  group FreeRTOS/inc
    FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable/inc
    FreeRTOS/portable/inc/: FreeRTOSConfig.h portmacro.h
  group FreeRTOS/portable/src
    FreeRTOS/portable/src/: heap_4.c port.c
  group FreeRTOS/portable/startup
    FreeRTOS/portable/startup/: portasm.s
  group FreeRTOS/src
    FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
