# IAR project FreeRTOS_v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4; HAL_CLOCK_ENABLED
  ICCARM.CCIncludePath2: Application\led\inc; $PROJ_DIR$; board\MKL46Z\inc; CMSIS\inc; FreeRTOS\config; FreeRTOS\inc; FreeRTOS\portable\inc; Application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\config
  OBJCOPY.OOCOutputFile: FreeRTOS_v1.srec
  ILINK.IlinkOutputFile: FreeRTOS_v1.out
  ILINK.IlinkIcfFile: board\MKL46Z\linker\MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group Application/led/inc
    Application/led/inc/: LED.h
  group Application/led/src
    Application/led/src/: LED.c
  group board/MKL46Z/inc
    board/MKL46Z/inc/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h system_MKL46Z4.h
  group board/MKL46Z/linker
    board/MKL46Z/linker/: MKL46Z256xxx4_flash.icf
  group board/MKL46Z/src
    board/MKL46Z/src/: system_MKL46Z4.c
  group board/MKL46Z/startup
    board/MKL46Z/startup/: startup_MKL46Z4.s
  group CMSIS/inc
    CMSIS/inc/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group FreeRTOS/config
    FreeRTOS/config/: FreeRTOSConfig.h
  group FreeRTOS/inc
    FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable/inc
    FreeRTOS/portable/inc/: portmacro.h
  group FreeRTOS/portable/src
    FreeRTOS/portable/src/: heap_4.c port.c
  group FreeRTOS/portable/startup
    FreeRTOS/portable/startup/: portasm.s
  group FreeRTOS/src
    FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
