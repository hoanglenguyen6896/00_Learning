# IAR project ass2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Application\led\inc; board\inc; CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ass2.srec
  ILINK.IlinkOutputFile: ass2.out
  ILINK.IlinkIcfFile: board\linker\MKL46Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group Application/led/inc
    Application/led/inc/: INIT.h LED.h
  group Application/led/src
    Application/led/src/: INIT.c LED.c
  group board/inc
    board/inc/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h system_MKL46Z4.h
  group board/linker
    board/linker/: MKL46Z256xxx4.icf MKL46Z256xxx4_flash.icf
  group board/src
    board/src/: system_MKL46Z4.c
  group board/startup
    board/startup/: startup_MKL46Z4.s
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
