# IAR project MockII.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: app\boot\inc; app\peripheral\inc; app\SREC\inc; app\utility\inc; board\CMSIS\Include; board\inc; board\startup; app\SRECapp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: board\startup
  OBJCOPY.OOCOutputFile: MockII.srec
  ILINK.IlinkOutputFile: MockII.out
  ILINK.IlinkIcfFile: board\linker\MKL46Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c
  group app/boot/inc
    app/boot/inc/: BOOT.h
  group app/boot/src
    app/boot/src/: BOOT.c
  group app/peripheral/inc
    app/peripheral/inc/: Flash.h GPIO.h UART0.h
  group app/peripheral/src
    app/peripheral/src/: Flash.c GPIO.c UART0.c
  group app/SREC/inc
    app/SREC/inc/: SREC.h
  group app/SREC/src
    app/SREC/src/: SREC.c
  group app/SRECapp/inc
    app/SRECapp/inc/: SRECapp.h
  group app/SRECapp/src
    app/SRECapp/src/: SRECapp.c
  group app/utility/inc
    app/utility/inc/: QUEUE.h
  group app/utility/src
    app/utility/src/: QUEUE.c
  group board/CMSIS/inc
    board/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group board/inc
    board/inc/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h
  group board/linker
    board/linker/: MKL46Z256xxx4.icf
  group board/startup
    board/startup/: startup_MKL46Z4.s
  group board/startup/inc
    board/startup/: system_MKL46Z4.h
  group board/startup/src
    board/startup/: system_MKL46Z4.c
