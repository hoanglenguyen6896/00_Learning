# IAR project UART0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application\inc; board\CMSIS\Include; board\inc; board\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: board\startup
  OBJCOPY.OOCOutputFile: UART0.srec
  ILINK.IlinkOutputFile: UART0.out
  ILINK.IlinkIcfFile: F:\Libraries\Documents\IAR\Assignment_UART0\board\linker\MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group Application/inc
    Application/inc/: QUEUE.h SREC.h UART0.h
  group Application/src
    Application/src/: QUEUE.c SREC.c UART0.c
  group board/inc
    board/inc/: MKL46Z256VLL4.h REG_ADDR.h
  group board/linker
    board/linker/: MKL46Z256xxx4_flash.icf
  group board/startup
    board/startup/: startup_MKL46Z4.s
  group board/startup/inc
    board/startup/: system_MKL46Z4.h
  group board/startup/src
    board/startup/: system_MKL46Z4.c
