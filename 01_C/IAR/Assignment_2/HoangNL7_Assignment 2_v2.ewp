# IAR project HoangNL7_Assignment 2_v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Application\inc; board\inc; board\startup; board\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Assignment_2_v2.srec
  ILINK.IlinkOutputFile: Assignment_2_v2.out
  ILINK.IlinkIcfFile: board\linker\MKL46Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group Application/inc
    Application/inc/: BUTTON.h HAL.h LED.h
  group Application/src
    Application/src/: BUTTON.c HAL.c LED.c
  group board/inc
    board/inc/: MKL46Z256VLL4.h REG_ADDR.h
  group board/startup
    board/startup/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
